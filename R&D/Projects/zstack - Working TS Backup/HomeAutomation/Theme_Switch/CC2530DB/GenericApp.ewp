# IAR project GenericApp.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; LEGACY_LCD_DEBUG; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\gp; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS; KEUS_GPIO_INTERRUPT_HANDLER_DISABLE; HAL_KEY=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_UART=TRUE; HAL_UART_ISR=1; HAL_UART_DMA=2; HAL_UART_DMA_RX_MAX=64; HAL_UART_DMA_TX_MAX=64
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\gp; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; ..\..\..\..\..\Components\keus
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; HAL_KEY=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; KEUS_GPIO_INTERRUPT_HANDLER_DISABLE; HAL_UART=TRUE; HAL_UART_ISR=1; HAL_UART_DMA=2; HAL_UART_DMA_RX_MAX=64; HAL_UART_DMA_TX_MAX=64; INT_HEAP_LEN=3172
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\gp; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; ..\..\..\..\..\Components\keus
  group App
    ../Source/: OSAL_GenericApp.c zcl_genericapp.c zcl_genericapp.h zcl_genericapp_data.c
  group BDB
    ../../../../../Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchLink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group GP
    ../../../../../Components/stack/GP/: cGP_stub.h dGP_stub.h gp_common.c gp_common.h gp_interface.h gp_proxyTbl.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/ZLIGHT/Config
    ../../../../../Components/hal/target/CC2530PMP4712/: hal_board_cfg.h
  group HAL/Target/ZLIGHT/Drivers
    ../../../../../Components/hal/target/CC2530PMP4712/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/ZLIGHT/Include
    ../../../../../Components/hal/target/CC2530PMP4712/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group keus_library
    ../../../../../COMPONENTS/keus/: keus_gpio_util.c keus_timer_util.c
    ../../../../../Components/keus/: keus_gpio_util.h keus_timer_util.h
  group keus_themeSwitch
    ../../../ZMain/TI2530DB/Theme_switch/: keusactions.c keusactions.h keusbutton.c keusbutton.h keusconstants.h keusMain.c keusuart.c keusuart.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_general.c zcl_general.h zcl_green_power.c zcl_green_power.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
